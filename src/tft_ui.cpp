#include "tft_ui.h"
#include <cstdio>
#include <cstring>
#include <initializer_list>
#include "driver/gpio.h"
#include "driver/spi_master.h"
#include "esp_check.h"
#include "esp_heap_caps.h"
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"

// Change these if they are in use on your board.
// This is the LCD's main SPI interface, NOT its T-CLK/T-DIN touch interface.
static constexpr gpio_num_t TFT_MOSI = GPIO_NUM_23; // SDI(MOSI)
static constexpr gpio_num_t TFT_SCLK = GPIO_NUM_18; // SCK
static constexpr gpio_num_t TFT_CS   = GPIO_NUM_5;  // CS
static constexpr gpio_num_t TFT_DC   = GPIO_NUM_4;  // DC
static constexpr gpio_num_t TFT_RST  = GPIO_NUM_32; // RESET
// TFT LED pin: supply as appropriate for the module; no backlight GPIO used here.
static constexpr int W = 320, H = 240, STRIPE = 16;
static constexpr uint16_t BG=0x000D, WHITE=0xFFFF, CYAN=0x07FF,
                          GREEN=0x07E0, GRAY=0xC618;
static spi_device_handle_t spi;
static uint16_t *pixels;
static int stripeY;

static void send(bool data, const uint8_t *buf, size_t len) {
  gpio_set_level(TFT_DC, data);
  spi_transaction_t t = {};
  t.length = len*8;
  t.tx_buffer = buf;
  ESP_ERROR_CHECK(spi_device_polling_transmit(spi,&t));
}
static void cmd(uint8_t c) { send(false,&c,1); }
static void args(std::initializer_list<uint8_t> bytes) {
  uint8_t buf[32]; int n=0;
  for (auto b:bytes) buf[n++]=b;
  send(true,buf,n);
}
static void window(int x1,int y1,int x2,int y2) {
  cmd(0x2A); args({uint8_t(x1>>8),uint8_t(x1),uint8_t(x2>>8),uint8_t(x2)});
  cmd(0x2B); args({uint8_t(y1>>8),uint8_t(y1),uint8_t(y2>>8),uint8_t(y2)});
  cmd(0x2C);
}
void tftUiInit() {
  gpio_config_t io = {};
  io.pin_bit_mask = (1ULL<<TFT_DC) | (1ULL<<TFT_RST);
  io.mode = GPIO_MODE_OUTPUT;
  ESP_ERROR_CHECK(gpio_config(&io));
  gpio_set_level(TFT_RST,0);
  vTaskDelay(pdMS_TO_TICKS(30));
  gpio_set_level(TFT_RST,1);
  vTaskDelay(pdMS_TO_TICKS(120));
  spi_bus_config_t bus = {};
  bus.mosi_io_num = TFT_MOSI;
  bus.miso_io_num = -1;
  bus.sclk_io_num = TFT_SCLK;
  bus.quadwp_io_num = -1;
  bus.quadhd_io_num = -1;
  bus.max_transfer_sz = W*STRIPE*2+16;
  ESP_ERROR_CHECK(spi_bus_initialize(SPI2_HOST,&bus,SPI_DMA_CH_AUTO));
  spi_device_interface_config_t dev = {};
  dev.clock_speed_hz = 20000000;
  dev.mode = 0;
  dev.spics_io_num = TFT_CS;
  dev.queue_size = 1;
  ESP_ERROR_CHECK(spi_bus_add_device(SPI2_HOST,&dev,&spi));
  // Standard ILI9341 init; TFT must have an ILI9341-compatible controller.
  cmd(0x01); vTaskDelay(pdMS_TO_TICKS(150));
  cmd(0x28);
  cmd(0x3A); args({0x55}); // RGB565, 16-bit pixels
  cmd(0x36); args({0x28}); // landscape orientation, BGR
  cmd(0x11); vTaskDelay(pdMS_TO_TICKS(120));
  cmd(0x29); vTaskDelay(pdMS_TO_TICKS(20));
  pixels=(uint16_t*)heap_caps_malloc(W*STRIPE*2,MALLOC_CAP_DMA|MALLOC_CAP_INTERNAL);
  ESP_ERROR_CHECK(pixels ? ESP_OK : ESP_ERR_NO_MEM);
}
static void rect(int x,int y,int w,int h,uint16_t color) {
  if(w<=0||h<=0) return;
  int x1=x<0?0:x, x2=x+w>W?W:x+w;
  int y1=y<stripeY?stripeY:y, y2=y+h>stripeY+STRIPE?stripeY+STRIPE:y+h;
  if(x2<=x1||y2<=y1) return;
  uint16_t c=(uint16_t)((color>>8)|(color<<8)); // SPI big-endian RGB565
  for(int yy=y1; yy<y2; ++yy)
    for(int xx=x1; xx<x2; ++xx) pixels[(yy-stripeY)*W+xx]=c;
}
static void outline(int x,int y,int w,int h,uint16_t color) {
  rect(x,y,w,2,color);rect(x,y+h-2,w,2,color);
  rect(x,y,2,h,color);rect(x+w-2,y,2,h,color);
}
// 6x10 bitmapped printable ASCII, generated from a fixed rasterized monospace font.
static const uint8_t FONT[95*10]={
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0a, 0x0a, 0x0a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0a, 0x0a, 0x1f, 0x14, 0x3e, 0x14, 0x14, 0x00, 0x00,
  0x00, 0x04, 0x0f, 0x14, 0x1c, 0x07, 0x05, 0x1e, 0x04, 0x00, 0x00, 0x38, 0x28, 0x3a, 0x0c, 0x17, 0x05, 0x07, 0x00, 0x00,
  0x00, 0x0e, 0x08, 0x0c, 0x15, 0x13, 0x12, 0x0d, 0x00, 0x00, 0x00, 0x04, 0x04, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x00, 0x08, 0x08, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x08, 0x00,
  0x00, 0x15, 0x0e, 0x0e, 0x15, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x04, 0x1f, 0x04, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x08, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x00,
  0x00, 0x0e, 0x11, 0x11, 0x15, 0x11, 0x11, 0x0e, 0x00, 0x00, 0x00, 0x1c, 0x04, 0x04, 0x04, 0x04, 0x04, 0x1f, 0x00, 0x00,
  0x00, 0x0e, 0x11, 0x01, 0x03, 0x06, 0x08, 0x1f, 0x00, 0x00, 0x00, 0x0e, 0x11, 0x01, 0x0e, 0x01, 0x11, 0x0e, 0x00, 0x00,
  0x00, 0x02, 0x06, 0x0a, 0x1a, 0x1f, 0x02, 0x02, 0x00, 0x00, 0x00, 0x1e, 0x10, 0x1e, 0x01, 0x01, 0x01, 0x1e, 0x00, 0x00,
  0x00, 0x0f, 0x18, 0x10, 0x1e, 0x11, 0x11, 0x0e, 0x00, 0x00, 0x00, 0x1f, 0x03, 0x02, 0x02, 0x04, 0x04, 0x08, 0x00, 0x00,
  0x00, 0x0e, 0x11, 0x11, 0x0e, 0x11, 0x11, 0x0e, 0x00, 0x00, 0x00, 0x0e, 0x11, 0x11, 0x0f, 0x01, 0x03, 0x1e, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x08, 0x08, 0x08,
  0x00, 0x00, 0x01, 0x0e, 0x10, 0x0e, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3e, 0x00, 0x3e, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x0e, 0x01, 0x0e, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1e, 0x02, 0x04, 0x08, 0x08, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x0e, 0x09, 0x17, 0x15, 0x15, 0x15, 0x17, 0x08, 0x06, 0x00, 0x04, 0x04, 0x0a, 0x0a, 0x0e, 0x11, 0x11, 0x00, 0x00,
  0x00, 0x1e, 0x11, 0x11, 0x1e, 0x11, 0x11, 0x1e, 0x00, 0x00, 0x00, 0x0f, 0x19, 0x10, 0x10, 0x10, 0x19, 0x0f, 0x00, 0x00,
  0x00, 0x1e, 0x13, 0x11, 0x11, 0x11, 0x13, 0x1e, 0x00, 0x00, 0x00, 0x1f, 0x10, 0x10, 0x1f, 0x10, 0x10, 0x1f, 0x00, 0x00,
  0x00, 0x1f, 0x10, 0x10, 0x1f, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x0e, 0x19, 0x10, 0x13, 0x11, 0x19, 0x0f, 0x00, 0x00,
  0x00, 0x11, 0x11, 0x11, 0x1f, 0x11, 0x11, 0x11, 0x00, 0x00, 0x00, 0x1f, 0x04, 0x04, 0x04, 0x04, 0x04, 0x1f, 0x00, 0x00,
  0x00, 0x0e, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0c, 0x00, 0x00, 0x00, 0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11, 0x00, 0x00,
  0x00, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1f, 0x00, 0x00, 0x00, 0x11, 0x1b, 0x1b, 0x15, 0x11, 0x11, 0x11, 0x00, 0x00,
  0x00, 0x11, 0x19, 0x19, 0x15, 0x13, 0x13, 0x11, 0x00, 0x00, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e, 0x00, 0x00,
  0x00, 0x1e, 0x11, 0x11, 0x1e, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e, 0x03, 0x00,
  0x00, 0x1e, 0x11, 0x11, 0x1e, 0x13, 0x11, 0x10, 0x00, 0x00, 0x00, 0x0e, 0x11, 0x10, 0x0e, 0x01, 0x11, 0x0e, 0x00, 0x00,
  0x00, 0x1f, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x00, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0e, 0x00, 0x00,
  0x00, 0x11, 0x11, 0x0a, 0x0a, 0x0a, 0x04, 0x04, 0x00, 0x00, 0x00, 0x21, 0x2d, 0x2d, 0x1e, 0x12, 0x12, 0x12, 0x00, 0x00,
  0x00, 0x11, 0x0a, 0x0a, 0x04, 0x0a, 0x0a, 0x11, 0x00, 0x00, 0x00, 0x11, 0x0a, 0x0a, 0x04, 0x04, 0x04, 0x04, 0x00, 0x00,
  0x00, 0x1f, 0x02, 0x02, 0x04, 0x08, 0x08, 0x1f, 0x00, 0x00, 0x0c, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0c, 0x00,
  0x00, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x0c, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0c, 0x00,
  0x00, 0x08, 0x14, 0x22, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3f,
  0x10, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1e, 0x01, 0x0f, 0x11, 0x1f, 0x00, 0x00,
  0x10, 0x10, 0x10, 0x1e, 0x11, 0x11, 0x11, 0x1e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x10, 0x10, 0x10, 0x0e, 0x00, 0x00,
  0x01, 0x01, 0x01, 0x0f, 0x11, 0x11, 0x11, 0x0f, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x11, 0x1f, 0x10, 0x0f, 0x00, 0x00,
  0x06, 0x08, 0x08, 0x1e, 0x08, 0x08, 0x08, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0x11, 0x11, 0x11, 0x0f, 0x01, 0x0e,
  0x10, 0x10, 0x10, 0x16, 0x19, 0x11, 0x11, 0x11, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0c, 0x04, 0x04, 0x04, 0x1f, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x1c, 0x04, 0x04, 0x04, 0x04, 0x04, 0x18, 0x10, 0x10, 0x10, 0x12, 0x14, 0x1c, 0x12, 0x11, 0x00, 0x00,
  0x38, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f, 0x15, 0x15, 0x15, 0x15, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x16, 0x19, 0x11, 0x11, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0e, 0x11, 0x11, 0x11, 0x0e, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1e, 0x11, 0x11, 0x11, 0x1e, 0x10, 0x10, 0x00, 0x00, 0x00, 0x0f, 0x11, 0x11, 0x11, 0x0f, 0x01, 0x01,
  0x00, 0x00, 0x00, 0x0f, 0x09, 0x08, 0x08, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0f, 0x10, 0x0f, 0x01, 0x1e, 0x00, 0x00,
  0x00, 0x08, 0x08, 0x1e, 0x08, 0x08, 0x08, 0x0e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0x11, 0x11, 0x11, 0x0f, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x11, 0x0a, 0x0a, 0x0a, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0x15, 0x0a, 0x0a, 0x0a, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1b, 0x0a, 0x04, 0x0a, 0x1b, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0x0a, 0x0a, 0x04, 0x04, 0x04, 0x18,
  0x00, 0x00, 0x00, 0x1f, 0x02, 0x04, 0x08, 0x1f, 0x00, 0x00, 0x06, 0x04, 0x04, 0x04, 0x18, 0x04, 0x04, 0x04, 0x06, 0x00,
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0c, 0x04, 0x04, 0x04, 0x03, 0x04, 0x04, 0x04, 0x0c, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1c, 0x03, 0x00, 0x00, 0x00, 0x00
};
static void glyph(int x,int y,char c,uint16_t color,int scale) {
  if(c<32||c>126) c='?';
  const uint8_t *g=&FONT[(c-32)*10];
  for(int yy=0;yy<10;yy++) for(int xx=0;xx<6;xx++)
    if(g[yy] & (1<<(5-xx))) rect(x+xx*scale,y+yy*scale,scale,scale,color);
}
static void str(int x,int y,const char *s,uint16_t color,int scale=1) {
  for(;*s && x<W-5*scale;s++,x+=7*scale) glyph(x,y,*s,color,scale);
}
static void item(int row, int selected,int start, const char *name,const char *val,bool editing) {
  const int y=68+row*23;
  if(selected==start+row) {
    outline(7,y-3,306,22,editing?GREEN:CYAN);
    str(13,y,editing?"*":">",CYAN);
  }
  str(30,y,name,WHITE);
  str(217,y,val,selected==start+row && editing ? GREEN:WHITE);
}
void tftUiDraw(const TftUiState &s) {
  const int total=4+s.otherCount;
  int first=0;
  if(s.selected>=4) first=s.selected-3;
  if(first>total-5) first=total-5;
  if(first<0) first=0;
  char val[32];
  for(stripeY=0;stripeY<H;stripeY+=STRIPE) {
    rect(0,stripeY,W,STRIPE,BG);
    str(12,8,"STEPPER SYNTH",WHITE,2);
    const char *status=s.recordingState==1?"REC":s.recordingState==2?"PLAY":s.recordingState==3?"PAUSE":s.activeVoices?"ON":"IDLE";
    str(255,11,status,s.recordingState==1?CYAN:GREEN,1);
    rect(8,33,304,2,GRAY);
    str(10,42,first<4?"VOLUME ENVELOPE":"SETTINGS",WHITE);
    str(245,42,s.editing?"EDIT":"BROWSE",GRAY);
    for(int row=0;row<5;row++) {
      int index=first+row;
      if(index>=total) break;
      switch(index) {
        case 0: snprintf(val,sizeof(val),"%d ms",s.attackMs);item(row,s.selected,index,"Attack",val,s.editing);break;
        case 1: snprintf(val,sizeof(val),"%d ms",s.decayMs);item(row,s.selected,index,"Decay",val,s.editing);break;
        case 2: snprintf(val,sizeof(val),"%d%%",s.sustainPct);item(row,s.selected,index,"Sustain",val,s.editing);break;
        case 3: snprintf(val,sizeof(val),"%d ms",s.releaseMs);item(row,s.selected,index,"Release",val,s.editing);break;
        default: item(row,s.selected,index,s.otherNames[index-4],s.otherValues[index-4],s.editing);break;
      }
    }
    rect(8,186,304,2,GRAY);
    snprintf(val,sizeof(val),"VOICES %d / 3",s.activeVoices);
    str(12,193,val,WHITE);
    str(210,193,"REC",GRAY);
    str(246,193,s.recordingState==1?"ON":s.hasRecording?"SAVED":"EMPTY",GREEN);
    rect(8,209,304,2,GRAY);
    str(12,216,s.editing?"Rotate: change value":"Rotate: select parameter",WHITE);
    str(12,228,s.editing?"Press: finish editing":"Press: edit value",GRAY);
    window(0,stripeY,W-1,stripeY+STRIPE-1);
    send(true,(uint8_t*)pixels,W*STRIPE*2);
  }
}
